# Keil uVision project Template.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\DSP_LIB\Include;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\PWM;..\HARDWARE\Encoder;..\HARDWARE\usart;..\HARDWARE\TIMES;..\HARDWARE\EXIT;..\MALLOC;..\APP\CONTROL;..\APP\PID;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\APP\besicmovement;..\HARDWARE\Map;..\HARDWARE\CAMEAR;..\HARDWARE\TOP;..\APP\RUNING_CONTROL;..\APP\PANDA;..\HARDWARE\near;..\HARDWARE\RTC;..\APP\REMOTECONTROL;..\APP\crawmanger
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c common.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group README
    ../: readme.txt
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group HARDWARE
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/Encoder/: encode.c
    ../HARDWARE/EXIT/: EXIT.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/PWM/: PWM.c
    ../HARDWARE/usart/: USART.c
    ../HARDWARE/TIMES/: TIMES.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/Map/: map_rx_tx.c
    ../HARDWARE/CAMEAR/: camear_tx_rx.c
    ../HARDWARE/TOP/: top_rx_tx.c
    ../HARDWARE/near/: near.c
    ../HARDWARE/RTC/: RTC.c
  group MALLOC
    ../MALLOC/: malloc.c
  group APP
    ../APP/besicmovement/: besicmovement.c
    ../APP/CONTROL/: control.c
    ../APP/PID/: pid.c
    ../APP/RUNING_CONTROL/: runingcontrol.c
    ../APP/PANDA/: panda.c
    ../APP/REMOTECONTROL/: remotecontrol.c
    ../APP/crawmanger/: crawmanger.c
